# IAR project cmsis_dspi_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 NXP MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKV31F512VLL12; TWR_KV31F120M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../../../../../CMSIS/Driver/Include; ../../../../..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKV31F51212/drivers; ../../../../../../../devices/MKV31F51212/cmsis_drivers; ../../../../../../../devices/MKV31F51212; ../../../../../../../devices/MKV31F51212/utilities/io; ../../../../../../../devices/MKV31F51212/utilities/str; ../../../../../../../devices/MKV31F51212/utilities/log; ../../../../../../../devices/MKV31F51212/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: cmsis_dspi_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MKV31F512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F512VLL12; TWR_KV31F120M; TOWER
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MKV31F51212/drivers/: fsl_port.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_dspi.h fsl_dspi.c fsl_dspi_edma.h fsl_dspi_edma.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
    ../../../../../../../devices/MKV31F51212/cmsis_drivers/: fsl_dspi_cmsis.h fsl_dspi_cmsis.c
  group startup
    ../../../../../../../devices/MKV31F51212/: system_MKV31F51212.c system_MKV31F51212.h
    ../../../../../../../devices/MKV31F51212/iar/: startup_MKV31F51212.s
  group utilities
    ../../../../../../../devices/MKV31F51212/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MKV31F51212/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MKV31F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MKV31F51212/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
